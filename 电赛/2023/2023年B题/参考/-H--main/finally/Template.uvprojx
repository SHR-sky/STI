# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\Public;.\APP\fft;.\APP\led;.\APP\my_lcd;.\APP\tftlcd;.\APP\spi;.\APP\key;.\APP\exti
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib arm_math.h
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_fsmc.c stm32f4xx_spi.c stm32f4xx_usart.c misc.c stm32f4xx_exti.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group APP
    ./APP/fft/: data.c ffttest.c
    ./APP/led/: led.c
    ./APP/my_lcd/: my_lcd.c
    ./APP/tftlcd/: tftlcd.c
    ./APP/spi/: spi.c
    ./APP/key/: key.c
    ./APP/exti/: exti.c
  group Public
    ./Public/: system.c SysTick.c usart.c
